File: KiMBo/config.sch (KiCad schematic (older format))
At the start: 18 parts, among them SW3 uSD_Boot

Commit message: Entry of additional component values
Parts:
- R102: renamed from R103; value R -> 100kΩ
- R103: renamed from R104; value R -> 100kΩ
- R104: renamed from R105; value R -> 100kΩ
- R105: renamed from R106; value R -> 100kΩ
- R106: renamed from R107; value R -> 100kΩ
- R107: renamed from R108; value R -> 100kΩ
- R108: renamed from R109; value R -> 100kΩ
- R109: renamed from R110; value R -> 100kΩ
- R110: renamed from R111; value R -> 100kΩ
- R111: renamed from R112; value R -> 100kΩ
- R112: renamed from R113; value R -> 100kΩ
- R113: renamed from R114; value R -> 100kΩ
- R114: renamed from R115; value R -> 100kΩ
- R115: renamed from R116; value R -> 100kΩ
- R116: renamed from R117; value R -> 100kΩ
- R117: renamed from R118; value R -> 100kΩ
- R118: renamed from R119; value R -> 100Ω
- SW3: value uSD_Boot -> μSD_Boot
Other:
- moved on the sheet: R102, R103, R104, R105, R106, R107, R108, R109, R110, R111, R112, R113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

Commit message: Add equivalent annotations document, associate more footprints
Parts:
- R101: renamed from R102; footprint (none) -> Resistors_SMD:R_0402
- R102: renamed from R103; footprint (none) -> Resistors_SMD:R_0402
- R103: renamed from R104; footprint (none) -> Resistors_SMD:R_0402
- R104: renamed from R105; footprint (none) -> Resistors_SMD:R_0402
- R105: renamed from R106; footprint (none) -> Resistors_SMD:R_0402
- R106: renamed from R107; footprint (none) -> Resistors_SMD:R_0402
- R107: renamed from R108; footprint (none) -> Resistors_SMD:R_0402
- R108: renamed from R109; footprint (none) -> Resistors_SMD:R_0402
- R109: renamed from R110; footprint (none) -> Resistors_SMD:R_0402
- R110: renamed from R111; footprint (none) -> Resistors_SMD:R_0402
- R111: renamed from R112; footprint (none) -> Resistors_SMD:R_0402
- R112: renamed from R113; footprint (none) -> Resistors_SMD:R_0402
- R113: renamed from R114; footprint (none) -> Resistors_SMD:R_0402
- R114: renamed from R115; footprint (none) -> Resistors_SMD:R_0402
- R115: renamed from R116; footprint (none) -> Resistors_SMD:R_0402
- R116: renamed from R117; footprint (none) -> Resistors_SMD:R_0402
- R117: renamed from R118; footprint (none) -> Resistors_SMD:R_0402
Changed lines of the file:
@@
 $EndDescr
 $Comp
-L R R106
+L R R105
 U 1 1 58A2324A
 P 4450 4600
-F 0 "R106" H 4450 4750 50  0000 L CNN
+F 0 "R105" H 4450 4750 50  0000 L CNN
 F 1 "100kΩ" H 4450 4450 50  0000 L CNN
-F 2 "" V 4380 4600 50  0001 C CNN
+F 2 "Resistors_SMD:R_0402" V 4380 4600 50  0001 C CNN
 F 3 "" H 4450 4600 50  0000 C CNN
 	1    4450 4600
@@
 $EndComp
 $Comp
-L R R107
+L R R106
 U 1 1 58A2326A
 P 4700 4600
-F 0 "R107" H 4700 4750 50  0000 L CNN
+F 0 "R106" H 4700 4750 50  0000 L CNN
 F 1 "100kΩ" H 4700 4450 50  0000 L CNN
-F 2 "" V 4630 4600 50  0001 C CNN
+F 2 "Resistors_SMD:R_0402" V 4630 4600 50  0001 C CNN
 F 3 "" H 4700 4600 50  0000 C CNN
 	1    4700 4600
@@
 $EndComp
 $Comp
-L R R108
+L R R107
 U 1 1 58A2328E
 P 4950 4600
-F 0 "R108" H 4950 4750 50  0000 L CNN
+F 0 "R107" H 4950 4750 50  0000 L CNN
 F 1 "100kΩ" H 4950 4450 50  0000 L CNN
-F 2 "" V 4880 4600 50  0001 C CNN
+F 2 "Resistors_SMD:R_0402" V 4880 4600 50  0001 C CNN
 F 3 "" H 4950 4600 50  0000 C CNN
 	1    4950 4600
@@
 $EndComp
 $Comp
-L R R109
+L R R108
 U 1 1 58A232B1
 P 5200 4600
-F 0 "R109" H 5200 4750 50  0000 L CNN
+F 0 "R108" H 5200 4750 50  0000 L CNN
 F 1 "100kΩ" H 5200 4450 50  0000 L CNN
-F 2 "" V 5130 4600 50  0001 C CNN
+F 2 "Resistors_SMD:R_0402" V 5130 4600 50  0001 C CNN
 F 3 "" H 5200 4600 50  0000 C CNN
 	1    5200 4600
@@
 $EndComp
 $Comp
-L R R110
+L R R109
 U 1 1 58A232DB
 P 5450 4600
-F 0 "R110" H 5450 4750 50  0000 L CNN
+F 0 "R109" H 5450 4750 50  0000 L CNN
 F 1 "100kΩ" H 5450 4450 50  0000 L CNN
-F 2 "" V 5380 4600 50  0001 C CNN
+F 2 "Resistors_SMD:R_0402" V 5380 4600 50  0001 C CNN
 F 3 "" H 5450 4600 50  0000 C CNN
 	1    5450 4600
@@
 $EndComp
 $Comp
-L R R111
+L R R110
 U 1 1 58A23304
 P 5700 4600
-F 0 "R111" H 5770 4646 50  0000 L CNN
+F 0 "R110" H 5770 4646 50  0000 L CNN
 F 1 "100kΩ" H 5770 4555 50  0000 L CNN
-F 2 "" V 5630 4600 50  0001 C CNN
+F 2 "Resistors_SMD:R_0402" V 5630 4600 50  0001 C CNN
 F 3 "" H 5700 4600 50  0000 C CNN
 	1    5700 4600
@@
 $EndComp
 $Comp
-L R R116
+L R R115
 U 1 1 58A23332
 P 6900 4600
-F 0 "R116" H 6900 4750 50  0000 L CNN
+F 0 "R115" H 6900 4750 50  0000 L CNN
 F 1 "100kΩ" H 6900 4450 50  0000 L CNN
-F 2 "" V 6830 4600 50  0001 C CNN
+F 2 "Resistors_SMD:R_0402" V 6830 4600 50  0001 C CNN
 F 3 "" H 6900 4600 50  0000 C CNN
 	1    6900 4600
@@
 $EndComp
 $Comp
-L R R117
+L R R116
 U 1 1 58A23361
 P 7150 4600
-F 0 "R117" H 7220 4646 50  0000 L CNN
+F 0 "R116" H 7220 4646 50  0000 L CNN
 F 1 "100kΩ" H 7220 4555 50  0000 L CNN
-F 2 "" V 7080 4600 50  0001 C CNN
+F 2 "Resistors_SMD:R_0402" V 7080 4600 50  0001 C CNN
 F 3 "" H 7150 4600 50  0000 C CNN
 	1    7150 4600
@@
 LCD.D11.R0--R3
 $Comp
-L R R105
+L R R104
 U 1 1 58A25F63
 P 4200 4600
-F 0 "R105" H 4200 4750 50  0000 L CNN
+F 0 "R104" H 4200 4750 50  0000 L CNN
 F 1 "100kΩ" H 4200 4450 50  0000 L CNN
-F 2 "" V 4130 4600 50  0001 C CNN
+F 2 "Resistors_SMD:R_0402" V 4130 4600 50  0001 C CNN
 F 3 "" H 4200 4600 50  0000 C CNN
 	1    4200 4600
@@
 $EndComp
 $Comp
-L R R104
+L R R103
 U 1 1 58A25F94
 P 3950 4600
-F 0 "R104" H 3950 4750 50  0000 L CNN
+F 0 "R103" H 3950 4750 50  0000 L CNN
 F 1 "100kΩ" H 3950 4450 50  0000 L CNN
-F 2 "" V 3880 4600 50  0001 C CNN
+F 2 "Resistors_SMD:R_0402" V 3880 4600 50  0001 C CNN
 F 3 "" H 3950 4600 50  0000 C CNN
 	1    3950 4600
@@
 $EndComp
 $Comp
-L R R102
+L R R101
 U 1 1 58A260DB
 P 3450 4600
-F 0 "R102" H 3520 4646 50  0000 L CNN
+F 0 "R101" H 3520 4646 50  0000 L CNN
 F 1 "100kΩ" H 3520 4555 50  0000 L CNN
-F 2 "" V 3380 4600 50  0001 C CNN
+F 2 "Resistors_SMD:R_0402" V 3380 4600 50  0001 C CNN
 F 3 "" H 3450 4600 50  0000 C CNN
 	1    3450 4600
@@
 $EndComp
 $Comp
-L GND #PWR0173
+L GND #PWR0172
 U 1 1 58A262E3
 P 4950 4850
-F 0 "#PWR0173" H 4950 4600 50  0001 C CNN
+F 0 "#PWR0172" H 4950 4600 50  0001 C CNN
 F 1 "GND" H 4955 4677 50  0000 C CNN
 F 2 "" H 4950 4850 50  0000 C CNN
@@
 $EndComp
 $Comp
-L R R115
+L R R114
 U 1 1 58A26A66
 P 6650 2550
-F 0 "R115" H 6720 2596 50  0000 L CNN
+F 0 "R114" H 6720 2596 50  0000 L CNN
 F 1 "100kΩ" H 6720 2505 50  0000 L CNN
-F 2 "" V 6580 2550 50  0001 C CNN
+F 2 "Resistors_SMD:R_0402" V 6580 2550 50  0001 C CNN
 F 3 "" H 6650 2550 50  0000 C CNN
 	1    6650 2550
@@
 $EndComp
 $Comp
-L R R114
+L R R113
 U 1 1 58A26AC4
 P 6400 2550
-F 0 "R114" H 6400 2700 50  0000 L CNN
+F 0 "R113" H 6400 2700 50  0000 L CNN
 F 1 "100kΩ" H 6400 2400 50  0000 L CNN
-F 2 "" V 6330 2550 50  0001 C CNN
+F 2 "Resistors_SMD:R_0402" V 6330 2550 50  0001 C CNN
 F 3 "" H 6400 2550 50  0000 C CNN
 	1    6400 2550
@@
 $EndComp
 $Comp
-L R R113
+L R R112
 U 1 1 58A26B05
 P 6150 2550
-F 0 "R113" H 6150 2700 50  0000 L CNN
+F 0 "R112" H 6150 2700 50  0000 L CNN
 F 1 "100kΩ" H 6150 2400 50  0000 L CNN
-F 2 "" V 6080 2550 50  0001 C CNN
+F 2 "Resistors_SMD:R_0402" V 6080 2550 50  0001 C CNN
 F 3 "" H 6150 2550 50  0000 C CNN
 	1    6150 2550
@@
 $EndComp
 $Comp
-L R R112
+L R R111
 U 1 1 58A26B4F
 P 5900 2550
-F 0 "R112" H 5900 2700 50  0000 L CNN
+F 0 "R111" H 5900 2700 50  0000 L CNN
 F 1 "100kΩ" H 5900 2400 50  0000 L CNN
-F 2 "" V 5830 2550 50  0001 C CNN
+F 2 "Resistors_SMD:R_0402" V 5830 2550 50  0001 C CNN
 F 3 "" H 5900 2550 50  0000 C CNN
 	1    5900 2550
@@
 $EndComp
 $Comp
-L R R103
+L R R102
 U 1 1 58A26BA2
 P 3700 2550
-F 0 "R103" H 3770 2596 50  0000 L CNN
+F 0 "R102" H 3770 2596 50  0000 L CNN
 F 1 "100kΩ" H 3770 2505 50  0000 L CNN
-F 2 "" V 3630 2550 50  0001 C CNN
+F 2 "Resistors_SMD:R_0402" V 3630 2550 50  0001 C CNN
 F 3 "" H 3700 2550 50  0000 C CNN
 	1    3700 2550
@@
 Connection ~ 5900 2350
 $Comp
-L R R118
+L R R117
 U 1 1 58A2A28E
 P 7450 2750
-F 0 "R118" V 7243 2750 50  0000 C CNN
+F 0 "R117" V 7243 2750 50  0000 C CNN
 F 1 "100Ω" V 7334 2750 50  0000 C CNN
-F 2 "" V 7380 2750 50  0001 C CNN
+F 2 "Resistors_SMD:R_0402" V 7380 2750 50  0001 C CNN
 F 3 "" H 7450 2750 50  0000 C CNN
 	1    7450 2750
@@
 Connection ~ 8150 2750
 $Comp
-L GND #PWR0174
+L GND #PWR0173
 U 1 1 58A2A814
 P 8150 2800
-F 0 "#PWR0174" H 8150 2550 50  0001 C CNN
+F 0 "#PWR0173" H 8150 2550 50  0001 C CNN
 F 1 "GND" H 8155 2627 50  0000 C CNN
 F 2 "" H 8150 2800 50  0000 C CNN
@@
 $EndComp
 $Comp
-L VDD_3V3B #PWR0175
+L VDD_3V3B #PWR0174
 U 1 1 5A05FAAA
 P 6150 2300
-F 0 "#PWR0175" H 6150 2150 50  0001 C CNN
+F 0 "#PWR0174" H 6150 2150 50  0001 C CNN
 F 1 "VDD_3V3B" H 6165 2473 50  0000 C CNN
 F 2 "" H 6150 2300 50  0000 C CNN

Commit message: Leave SPI0 free for a display, reassign pins so SPI1 is available
Fix some typos/errors
Parts:
- renumbered R101 to R103, R102 to R104, R103 to R105, R104 to R106, R105 to R107, R106 to R108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
Changed lines of the file:
@@
 $EndDescr
 $Comp
-L R R105
+L R R107
 U 1 1 58A2324A
 P 4450 4600
-F 0 "R105" H 4450 4750 50  0000 L CNN
+F 0 "R107" H 4450 4750 50  0000 L CNN
 F 1 "100kΩ" H 4450 4450 50  0000 L CNN
 F 2 "Resistors_SMD:R_0402" V 4380 4600 50  0001 C CNN
@@
 $EndComp
 $Comp
-L R R106
+L R R108
 U 1 1 58A2326A
 P 4700 4600
-F 0 "R106" H 4700 4750 50  0000 L CNN
+F 0 "R108" H 4700 4750 50  0000 L CNN
 F 1 "100kΩ" H 4700 4450 50  0000 L CNN
 F 2 "Resistors_SMD:R_0402" V 4630 4600 50  0001 C CNN
@@
 $EndComp
 $Comp
-L R R107
+L R R109
 U 1 1 58A2328E
 P 4950 4600
-F 0 "R107" H 4950 4750 50  0000 L CNN
+F 0 "R109" H 4950 4750 50  0000 L CNN
 F 1 "100kΩ" H 4950 4450 50  0000 L CNN
 F 2 "Resistors_SMD:R_0402" V 4880 4600 50  0001 C CNN
@@
 $EndComp
 $Comp
-L R R108
+L R R110
 U 1 1 58A232B1
 P 5200 4600
-F 0 "R108" H 5200 4750 50  0000 L CNN
+F 0 "R110" H 5200 4750 50  0000 L CNN
 F 1 "100kΩ" H 5200 4450 50  0000 L CNN
 F 2 "Resistors_SMD:R_0402" V 5130 4600 50  0001 C CNN
@@
 $EndComp
 $Comp
-L R R109
+L R R111
 U 1 1 58A232DB
 P 5450 4600
-F 0 "R109" H 5450 4750 50  0000 L CNN
+F 0 "R111" H 5450 4750 50  0000 L CNN
 F 1 "100kΩ" H 5450 4450 50  0000 L CNN
 F 2 "Resistors_SMD:R_0402" V 5380 4600 50  0001 C CNN
@@
 $EndComp
 $Comp
-L R R110
+L R R112
 U 1 1 58A23304
 P 5700 4600
-F 0 "R110" H 5770 4646 50  0000 L CNN
+F 0 "R112" H 5770 4646 50  0000 L CNN
 F 1 "100kΩ" H 5770 4555 50  0000 L CNN
 F 2 "Resistors_SMD:R_0402" V 5630 4600 50  0001 C CNN
@@
 $EndComp
 $Comp
-L R R115
+L R R117
 U 1 1 58A23332
 P 6900 4600
-F 0 "R115" H 6900 4750 50  0000 L CNN
+F 0 "R117" H 6900 4750 50  0000 L CNN
 F 1 "100kΩ" H 6900 4450 50  0000 L CNN
 F 2 "Resistors_SMD:R_0402" V 6830 4600 50  0001 C CNN
@@
 $EndComp
 $Comp
-L R R116
+L R R118
 U 1 1 58A23361
 P 7150 4600
-F 0 "R116" H 7220 4646 50  0000 L CNN
+F 0 "R118" H 7220 4646 50  0000 L CNN
 F 1 "100kΩ" H 7220 4555 50  0000 L CNN
 F 2 "Resistors_SMD:R_0402" V 7080 4600 50  0001 C CNN
@@
 LCD.D11.R0--R3
 $Comp
-L R R104
+L R R106
 U 1 1 58A25F63
 P 4200 4600
-F 0 "R104" H 4200 4750 50  0000 L CNN
+F 0 "R106" H 4200 4750 50  0000 L CNN
 F 1 "100kΩ" H 4200 4450 50  0000 L CNN
 F 2 "Resistors_SMD:R_0402" V 4130 4600 50  0001 C CNN
@@
 $EndComp
 $Comp
-L R R103
+L R R105
 U 1 1 58A25F94
 P 3950 4600
-F 0 "R103" H 3950 4750 50  0000 L CNN
+F 0 "R105" H 3950 4750 50  0000 L CNN
 F 1 "100kΩ" H 3950 4450 50  0000 L CNN
 F 2 "Resistors_SMD:R_0402" V 3880 4600 50  0001 C CNN
@@
 $EndComp
 $Comp
-L R R101
+L R R103
 U 1 1 58A260DB
 P 3450 4600
-F 0 "R101" H 3520 4646 50  0000 L CNN
+F 0 "R103" H 3520 4646 50  0000 L CNN
 F 1 "100kΩ" H 3520 4555 50  0000 L CNN
 F 2 "Resistors_SMD:R_0402" V 3380 4600 50  0001 C CNN
@@
 $EndComp
 $Comp
-L GND #PWR0172
+L GND #PWR0171
 U 1 1 58A262E3
 P 4950 4850
-F 0 "#PWR0172" H 4950 4600 50  0001 C CNN
+F 0 "#PWR0171" H 4950 4600 50  0001 C CNN
 F 1 "GND" H 4955 4677 50  0000 C CNN
 F 2 "" H 4950 4850 50  0000 C CNN
@@
 $EndComp
 $Comp
-L R R114
+L R R116
 U 1 1 58A26A66
 P 6650 2550
-F 0 "R114" H 6720 2596 50  0000 L CNN
+F 0 "R116" H 6720 2596 50  0000 L CNN
 F 1 "100kΩ" H 6720 2505 50  0000 L CNN
 F 2 "Resistors_SMD:R_0402" V 6580 2550 50  0001 C CNN
@@
 $EndComp
 $Comp
-L R R113
+L R R115
 U 1 1 58A26AC4
 P 6400 2550
-F 0 "R113" H 6400 2700 50  0000 L CNN
+F 0 "R115" H 6400 2700 50  0000 L CNN
 F 1 "100kΩ" H 6400 2400 50  0000 L CNN
 F 2 "Resistors_SMD:R_0402" V 6330 2550 50  0001 C CNN
@@
 $EndComp
 $Comp
-L R R112
+L R R114
 U 1 1 58A26B05
 P 6150 2550
-F 0 "R112" H 6150 2700 50  0000 L CNN
+F 0 "R114" H 6150 2700 50  0000 L CNN
 F 1 "100kΩ" H 6150 2400 50  0000 L CNN
 F 2 "Resistors_SMD:R_0402" V 6080 2550 50  0001 C CNN
@@
 $EndComp
 $Comp
-L R R111
+L R R113
 U 1 1 58A26B4F
 P 5900 2550
-F 0 "R111" H 5900 2700 50  0000 L CNN
+F 0 "R113" H 5900 2700 50  0000 L CNN
 F 1 "100kΩ" H 5900 2400 50  0000 L CNN
 F 2 "Resistors_SMD:R_0402" V 5830 2550 50  0001 C CNN
@@
 $EndComp
 $Comp
-L R R102
+L R R104
 U 1 1 58A26BA2
 P 3700 2550
-F 0 "R102" H 3770 2596 50  0000 L CNN
+F 0 "R104" H 3770 2596 50  0000 L CNN
 F 1 "100kΩ" H 3770 2505 50  0000 L CNN
 F 2 "Resistors_SMD:R_0402" V 3630 2550 50  0001 C CNN
@@
 Connection ~ 5900 2350
 $Comp
-L R R117
+L R R119
 U 1 1 58A2A28E
 P 7450 2750
-F 0 "R117" V 7243 2750 50  0000 C CNN
+F 0 "R119" V 7243 2750 50  0000 C CNN
 F 1 "100Ω" V 7334 2750 50  0000 C CNN
 F 2 "Resistors_SMD:R_0402" V 7380 2750 50  0001 C CNN
@@
 Connection ~ 8150 2750
 $Comp
-L GND #PWR0173
+L GND #PWR0172
 U 1 1 58A2A814
 P 8150 2800
-F 0 "#PWR0173" H 8150 2550 50  0001 C CNN
+F 0 "#PWR0172" H 8150 2550 50  0001 C CNN
 F 1 "GND" H 8155 2627 50  0000 C CNN
 F 2 "" H 8150 2800 50  0000 C CNN
@@
 $EndComp
 $Comp
-L VDD_3V3B #PWR0174
+L VDD_3V3B #PWR0173
 U 1 1 5A05FAAA
 P 6150 2300
-F 0 "#PWR0174" H 6150 2150 50  0001 C CNN
+F 0 "#PWR0173" H 6150 2150 50  0001 C CNN
 F 1 "VDD_3V3B" H 6165 2473 50  0000 C CNN
 F 2 "" H 6150 2300 50  0000 C CNN

Commit message: Use fixed 5V LM2592HV Buck, include SPI0 header for LCD
Parts:
- renumbered R103 to R100, R104 to R101, R105 to R102, R106 to R103, R107 to R104, R108 to R105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
Changed lines of the file:
@@
 $EndDescr
 $Comp
-L R R107
+L R R104
 U 1 1 58A2324A
 P 4450 4600
-F 0 "R107" H 4450 4750 50  0000 L CNN
+F 0 "R104" H 4450 4750 50  0000 L CNN
 F 1 "100kΩ" H 4450 4450 50  0000 L CNN
 F 2 "Resistors_SMD:R_0402" V 4380 4600 50  0001 C CNN
@@
 $EndComp
 $Comp
-L R R108
+L R R105
 U 1 1 58A2326A
 P 4700 4600
-F 0 "R108" H 4700 4750 50  0000 L CNN
+F 0 "R105" H 4700 4750 50  0000 L CNN
 F 1 "100kΩ" H 4700 4450 50  0000 L CNN
 F 2 "Resistors_SMD:R_0402" V 4630 4600 50  0001 C CNN
@@
 $EndComp
 $Comp
-L R R109
+L R R106
 U 1 1 58A2328E
 P 4950 4600
-F 0 "R109" H 4950 4750 50  0000 L CNN
+F 0 "R106" H 4950 4750 50  0000 L CNN
 F 1 "100kΩ" H 4950 4450 50  0000 L CNN
 F 2 "Resistors_SMD:R_0402" V 4880 4600 50  0001 C CNN
@@
 $EndComp
 $Comp
-L R R110
+L R R107
 U 1 1 58A232B1
 P 5200 4600
-F 0 "R110" H 5200 4750 50  0000 L CNN
+F 0 "R107" H 5200 4750 50  0000 L CNN
 F 1 "100kΩ" H 5200 4450 50  0000 L CNN
 F 2 "Resistors_SMD:R_0402" V 5130 4600 50  0001 C CNN
@@
 $EndComp
 $Comp
-L R R111
+L R R108
 U 1 1 58A232DB
 P 5450 4600
-F 0 "R111" H 5450 4750 50  0000 L CNN
+F 0 "R108" H 5450 4750 50  0000 L CNN
 F 1 "100kΩ" H 5450 4450 50  0000 L CNN
 F 2 "Resistors_SMD:R_0402" V 5380 4600 50  0001 C CNN
@@
 $EndComp
 $Comp
-L R R112
+L R R109
 U 1 1 58A23304
 P 5700 4600
-F 0 "R112" H 5770 4646 50  0000 L CNN
+F 0 "R109" H 5770 4646 50  0000 L CNN
 F 1 "100kΩ" H 5770 4555 50  0000 L CNN
 F 2 "Resistors_SMD:R_0402" V 5630 4600 50  0001 C CNN
@@
 $EndComp
 $Comp
-L R R117
+L R R114
 U 1 1 58A23332
 P 6900 4600
-F 0 "R117" H 6900 4750 50  0000 L CNN
+F 0 "R114" H 6900 4750 50  0000 L CNN
 F 1 "100kΩ" H 6900 4450 50  0000 L CNN
 F 2 "Resistors_SMD:R_0402" V 6830 4600 50  0001 C CNN
@@
 $EndComp
 $Comp
-L R R118
+L R R115
 U 1 1 58A23361
 P 7150 4600
-F 0 "R118" H 7220 4646 50  0000 L CNN
+F 0 "R115" H 7220 4646 50  0000 L CNN
 F 1 "100kΩ" H 7220 4555 50  0000 L CNN
 F 2 "Resistors_SMD:R_0402" V 7080 4600 50  0001 C CNN
@@
 LCD.D11.R0--R3
 $Comp
-L R R106
+L R R103
 U 1 1 58A25F63
 P 4200 4600
-F 0 "R106" H 4200 4750 50  0000 L CNN
+F 0 "R103" H 4200 4750 50  0000 L CNN
 F 1 "100kΩ" H 4200 4450 50  0000 L CNN
 F 2 "Resistors_SMD:R_0402" V 4130 4600 50  0001 C CNN
@@
 $EndComp
 $Comp
-L R R105
+L R R102
 U 1 1 58A25F94
 P 3950 4600
-F 0 "R105" H 3950 4750 50  0000 L CNN
+F 0 "R102" H 3950 4750 50  0000 L CNN
 F 1 "100kΩ" H 3950 4450 50  0000 L CNN
 F 2 "Resistors_SMD:R_0402" V 3880 4600 50  0001 C CNN
@@
 $EndComp
 $Comp
-L R R103
+L R R100
 U 1 1 58A260DB
 P 3450 4600
-F 0 "R103" H 3520 4646 50  0000 L CNN
+F 0 "R100" H 3520 4646 50  0000 L CNN
 F 1 "100kΩ" H 3520 4555 50  0000 L CNN
 F 2 "Resistors_SMD:R_0402" V 3380 4600 50  0001 C CNN
@@
 $EndComp
 $Comp
-L GND #PWR0171
+L GND #PWR0166
 U 1 1 58A262E3
 P 4950 4850
-F 0 "#PWR0171" H 4950 4600 50  0001 C CNN
+F 0 "#PWR0166" H 4950 4600 50  0001 C CNN
 F 1 "GND" H 4955 4677 50  0000 C CNN
 F 2 "" H 4950 4850 50  0000 C CNN
@@
 $EndComp
 $Comp
-L R R116
+L R R113
 U 1 1 58A26A66
 P 6650 2550
-F 0 "R116" H 6720 2596 50  0000 L CNN
+F 0 "R113" H 6720 2596 50  0000 L CNN
 F 1 "100kΩ" H 6720 2505 50  0000 L CNN
 F 2 "Resistors_SMD:R_0402" V 6580 2550 50  0001 C CNN
@@
 $EndComp
 $Comp
-L R R115
+L R R112
 U 1 1 58A26AC4
 P 6400 2550
-F 0 "R115" H 6400 2700 50  0000 L CNN
+F 0 "R112" H 6400 2700 50  0000 L CNN
 F 1 "100kΩ" H 6400 2400 50  0000 L CNN
 F 2 "Resistors_SMD:R_0402" V 6330 2550 50  0001 C CNN
@@
 $EndComp
 $Comp
-L R R114
+L R R111
 U 1 1 58A26B05
 P 6150 2550
-F 0 "R114" H 6150 2700 50  0000 L CNN
+F 0 "R111" H 6150 2700 50  0000 L CNN
 F 1 "100kΩ" H 6150 2400 50  0000 L CNN
 F 2 "Resistors_SMD:R_0402" V 6080 2550 50  0001 C CNN
@@
 $EndComp
 $Comp
-L R R113
+L R R110
 U 1 1 58A26B4F
 P 5900 2550
-F 0 "R113" H 5900 2700 50  0000 L CNN
+F 0 "R110" H 5900 2700 50  0000 L CNN
 F 1 "100kΩ" H 5900 2400 50  0000 L CNN
 F 2 "Resistors_SMD:R_0402" V 5830 2550 50  0001 C CNN
@@
 $EndComp
 $Comp
-L R R104
+L R R101
 U 1 1 58A26BA2
 P 3700 2550
-F 0 "R104" H 3770 2596 50  0000 L CNN
+F 0 "R101" H 3770 2596 50  0000 L CNN
 F 1 "100kΩ" H 3770 2505 50  0000 L CNN
 F 2 "Resistors_SMD:R_0402" V 3630 2550 50  0001 C CNN
@@
 Connection ~ 5900 2350
 $Comp
-L R R119
+L R R116
 U 1 1 58A2A28E
 P 7450 2750
-F 0 "R119" V 7243 2750 50  0000 C CNN
+F 0 "R116" V 7243 2750 50  0000 C CNN
 F 1 "100Ω" V 7334 2750 50  0000 C CNN
 F 2 "Resistors_SMD:R_0402" V 7380 2750 50  0001 C CNN
@@
 Connection ~ 8150 2750
 $Comp
-L GND #PWR0172
+L GND #PWR0167
 U 1 1 58A2A814
 P 8150 2800
-F 0 "#PWR0172" H 8150 2550 50  0001 C CNN
+F 0 "#PWR0167" H 8150 2550 50  0001 C CNN
 F 1 "GND" H 8155 2627 50  0000 C CNN
 F 2 "" H 8150 2800 50  0000 C CNN
@@
 $EndComp
 $Comp
-L VDD_3V3B #PWR0173
+L VDD_3V3B #PWR0168
 U 1 1 5A05FAAA
 P 6150 2300
-F 0 "#PWR0173" H 6150 2150 50  0001 C CNN
+F 0 "#PWR0168" H 6150 2150 50  0001 C CNN
 F 1 "VDD_3V3B" H 6165 2473 50  0000 C CNN
 F 2 "" H 6150 2300 50  0000 C CNN

Commit message: Assocate more footprints
Parts:
- R100, R101, R102, R103, R104, R105, R106, R107, R108, R109, R110, R111, R112, R113, R114, R115, R116: footprint Resistors_SMD:R_0402 -> Resistors_SMD:R_0603
Changed lines of the file:
@@
 F 0 "R104" H 4450 4750 50  0000 L CNN
 F 1 "100kΩ" H 4450 4450 50  0000 L CNN
-F 2 "Resistors_SMD:R_0402" V 4380 4600 50  0001 C CNN
+F 2 "Resistors_SMD:R_0603" V 4380 4600 50  0001 C CNN
 F 3 "" H 4450 4600 50  0000 C CNN
 	1    4450 4600
@@
 F 0 "R105" H 4700 4750 50  0000 L CNN
 F 1 "100kΩ" H 4700 4450 50  0000 L CNN
-F 2 "Resistors_SMD:R_0402" V 4630 4600 50  0001 C CNN
+F 2 "Resistors_SMD:R_0603" V 4630 4600 50  0001 C CNN
 F 3 "" H 4700 4600 50  0000 C CNN
 	1    4700 4600
@@
 F 0 "R106" H 4950 4750 50  0000 L CNN
 F 1 "100kΩ" H 4950 4450 50  0000 L CNN
-F 2 "Resistors_SMD:R_0402" V 4880 4600 50  0001 C CNN
+F 2 "Resistors_SMD:R_0603" V 4880 4600 50  0001 C CNN
 F 3 "" H 4950 4600 50  0000 C CNN
 	1    4950 4600
@@
 F 0 "R107" H 5200 4750 50  0000 L CNN
 F 1 "100kΩ" H 5200 4450 50  0000 L CNN
-F 2 "Resistors_SMD:R_0402" V 5130 4600 50  0001 C CNN
+F 2 "Resistors_SMD:R_0603" V 5130 4600 50  0001 C CNN
 F 3 "" H 5200 4600 50  0000 C CNN
 	1    5200 4600
@@
 F 0 "R108" H 5450 4750 50  0000 L CNN
 F 1 "100kΩ" H 5450 4450 50  0000 L CNN
-F 2 "Resistors_SMD:R_0402" V 5380 4600 50  0001 C CNN
+F 2 "Resistors_SMD:R_0603" V 5380 4600 50  0001 C CNN
 F 3 "" H 5450 4600 50  0000 C CNN
 	1    5450 4600
@@
 F 0 "R109" H 5770 4646 50  0000 L CNN
 F 1 "100kΩ" H 5770 4555 50  0000 L CNN
-F 2 "Resistors_SMD:R_0402" V 5630 4600 50  0001 C CNN
+F 2 "Resistors_SMD:R_0603" V 5630 4600 50  0001 C CNN
 F 3 "" H 5700 4600 50  0000 C CNN
 	1    5700 4600
@@
 F 0 "R114" H 6900 4750 50  0000 L CNN
 F 1 "100kΩ" H 6900 4450 50  0000 L CNN
-F 2 "Resistors_SMD:R_0402" V 6830 4600 50  0001 C CNN
+F 2 "Resistors_SMD:R_0603" V 6830 4600 50  0001 C CNN
 F 3 "" H 6900 4600 50  0000 C CNN
 	1    6900 4600
@@
 F 0 "R115" H 7220 4646 50  0000 L CNN
 F 1 "100kΩ" H 7220 4555 50  0000 L CNN
-F 2 "Resistors_SMD:R_0402" V 7080 4600 50  0001 C CNN
+F 2 "Resistors_SMD:R_0603" V 7080 4600 50  0001 C CNN
 F 3 "" H 7150 4600 50  0000 C CNN
 	1    7150 4600
@@
 F 0 "R103" H 4200 4750 50  0000 L CNN
 F 1 "100kΩ" H 4200 4450 50  0000 L CNN
-F 2 "Resistors_SMD:R_0402" V 4130 4600 50  0001 C CNN
+F 2 "Resistors_SMD:R_0603" V 4130 4600 50  0001 C CNN
 F 3 "" H 4200 4600 50  0000 C CNN
 	1    4200 4600
@@
 F 0 "R102" H 3950 4750 50  0000 L CNN
 F 1 "100kΩ" H 3950 4450 50  0000 L CNN
-F 2 "Resistors_SMD:R_0402" V 3880 4600 50  0001 C CNN
+F 2 "Resistors_SMD:R_0603" V 3880 4600 50  0001 C CNN
 F 3 "" H 3950 4600 50  0000 C CNN
 	1    3950 4600
@@
 F 0 "R100" H 3520 4646 50  0000 L CNN
 F 1 "100kΩ" H 3520 4555 50  0000 L CNN
-F 2 "Resistors_SMD:R_0402" V 3380 4600 50  0001 C CNN
+F 2 "Resistors_SMD:R_0603" V 3380 4600 50  0001 C CNN
 F 3 "" H 3450 4600 50  0000 C CNN
 	1    3450 4600
@@
 F 0 "R113" H 6720 2596 50  0000 L CNN
 F 1 "100kΩ" H 6720 2505 50  0000 L CNN
-F 2 "Resistors_SMD:R_0402" V 6580 2550 50  0001 C CNN
+F 2 "Resistors_SMD:R_0603" V 6580 2550 50  0001 C CNN
 F 3 "" H 6650 2550 50  0000 C CNN
 	1    6650 2550
@@
 F 0 "R112" H 6400 2700 50  0000 L CNN
 F 1 "100kΩ" H 6400 2400 50  0000 L CNN
-F 2 "Resistors_SMD:R_0402" V 6330 2550 50  0001 C CNN
+F 2 "Resistors_SMD:R_0603" V 6330 2550 50  0001 C CNN
 F 3 "" H 6400 2550 50  0000 C CNN
 	1    6400 2550
@@
 F 0 "R111" H 6150 2700 50  0000 L CNN
 F 1 "100kΩ" H 6150 2400 50  0000 L CNN
-F 2 "Resistors_SMD:R_0402" V 6080 2550 50  0001 C CNN
+F 2 "Resistors_SMD:R_0603" V 6080 2550 50  0001 C CNN
 F 3 "" H 6150 2550 50  0000 C CNN
 	1    6150 2550
@@
 F 0 "R110" H 5900 2700 50  0000 L CNN
 F 1 "100kΩ" H 5900 2400 50  0000 L CNN
-F 2 "Resistors_SMD:R_0402" V 5830 2550 50  0001 C CNN
+F 2 "Resistors_SMD:R_0603" V 5830 2550 50  0001 C CNN
 F 3 "" H 5900 2550 50  0000 C CNN
 	1    5900 2550
@@
 F 0 "R101" H 3770 2596 50  0000 L CNN
 F 1 "100kΩ" H 3770 2505 50  0000 L CNN
-F 2 "Resistors_SMD:R_0402" V 3630 2550 50  0001 C CNN
+F 2 "Resistors_SMD:R_0603" V 3630 2550 50  0001 C CNN
 F 3 "" H 3700 2550 50  0000 C CNN
 	1    3700 2550
@@
 F 0 "R116" V 7243 2750 50  0000 C CNN
 F 1 "100Ω" V 7334 2750 50  0000 C CNN
-F 2 "Resistors_SMD:R_0402" V 7380 2750 50  0001 C CNN
+F 2 "Resistors_SMD:R_0603" V 7380 2750 50  0001 C CNN
 F 3 "" H 7450 2750 50  0000 C CNN
 	1    7450 2750
